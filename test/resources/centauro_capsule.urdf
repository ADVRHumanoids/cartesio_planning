Commit message: wip

File: test/resources/centauro_capsule.urdf (robot description, URDF)
Before this commit: robot centauro, 98 links, 97 joints
Joints:
- joint reference: origin xyz=0.0 0.0 1.0 rpy=0 0 1.57 -> xyz=0.0 0.0 1.0 rpy=0 0 0
